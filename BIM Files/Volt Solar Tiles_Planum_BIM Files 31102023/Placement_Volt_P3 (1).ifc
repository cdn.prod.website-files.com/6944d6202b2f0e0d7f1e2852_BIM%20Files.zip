Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: db1e20dd-0823-464d-a91a-4145aae37559, NumberOfSaves: 20], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Project Number
Time: 2025-10-01T15:05:36+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 3000

# IfcBuildingElementProxy: Volt_P3.5 Solar Tile:Volt_P3.5 Solar Tile (40)
In: Level 1
Type - Material: Anodised Black Aluminum, <Unnamed>, 3.2mm Tempered Solar Glass, PERC Solar Cells
Type - Other - Category: Electrical Equipment; Family Name: Volt_P3.5 Solar Tile
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Height: 443.1 mm; Width: 1907.5 mm
Type - Identity Data - Cells: PERC Solar Cells; Dimesions: 1907.5 × 443.1 mm (P3.5 series); Electrical Rating: Vmp, Voc, Imp, Isc; Frame: Anodised Black Aluminum; Glass: 3.2mm Tempered Solar Glass; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Power Rating: 105 W; Type Name: Volt_P3.5 Solar Tile; Warranties: 10 year product, 25 year performance; Weight: 13.8 Kg
Pset_BuildingElementProxyCommon - Reference: Volt_P3.5 Solar Tile; sets with these values: 2
Other - Family: Volt_P3.5 Solar Tile; Family and Type: Volt_P3.5 Solar Tile: Volt_P3.5 Solar Tile; Reverse: yes; Straight: no; Type: Volt_P3.5 Solar Tile; Type Id: 344493
Constraints - Elevation from Level: 0 mm; Work Plane: <not associated>
Dimensions - Angle: 10 deg; Area: 1.93647 m2; Reverse angle: -20 deg; Volume: 0.00378629 m3
Electrical - Circuiting - Circuit Numbering Option: Default; Feed Through Lugs: yes; MCB Rating: 1 A; SubFeed Lugs: yes
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Branch Circuit Apparent Load Phase A: 0 W; Branch Circuit Apparent Load Phase B: 0 W; Branch Circuit Apparent Load Phase C: 0 W; Feed Through Lugs Apparent Load Phase A: 0 W; Feed Through Lugs Apparent Load Phase B: 0 W; Feed Through Lugs Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
Phasing - Phase Created: New Construction
Name (Volt_P3.5 Solar Tile:Volt_P3.5 Solar Tile:...) | Offset from Host (mm) | Mark
350781 | 56.1044 | 144
352433 | 66.3129 | 149
352701 | 56.1044 | 150
352703 | 66.3129 | 151
352819 | 56.1044 | 152
352821 | 66.3129 | 153
352822 | 56.1044 | 154
352823 | 66.3129 | 155
352996 | 49.2451 | 164
352998 | 59.4537 | 165
352999 | 49.2451 | 166
353000 | 59.4537 | 167
353001 | 49.2451 | 168
353002 | 59.4537 | 169
353003 | 49.2451 | 170
353004 | 59.4537 | 171
353068 | 49.2451 | 172
353070 | 59.4537 | 173
353071 | 49.2451 | 174
353072 | 59.4537 | 175
353073 | 49.2451 | 176
353074 | 59.4537 | 177
353075 | 49.2451 | 178
353076 | 59.4537 | 179
353097 | 49.2451 | 180
353099 | 59.4537 | 181
353100 | 49.2451 | 182
353101 | 59.4537 | 183
353102 | 49.2451 | 184
353103 | 59.4537 | 185
353104 | 49.2451 | 186
353105 | 59.4537 | 187
353128 | 49.2451 | 188
353130 | 59.4537 | 189
353131 | 49.2451 | 190
353132 | 59.4537 | 191
353133 | 49.2451 | 192
353134 | 59.4537 | 193
353135 | 49.2451 | 194
353136 | 59.4537 | 195

# IfcFlowSegment: Gutter:Standard:19886, Gutter:Standard:353370
In: Level 1
Type - ElementType: Gutter:Standard:19886; PredefinedType: GUTTER
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 7700 mm; sets with these values: 3
Pset_PipeSegmentTypeGutter - Slope: 72.9862 deg
Other - Category: Roofs: Gutters; Family: Gutter; Family and Type: Gutter: Standard; Type: Standard; Type Id: 19886
Constraints - Horizontal Profile Offset: 5 mm; Vertical Profile Offset: 170 mm
Phasing - Phase Created: New Construction
Profile - Angle: 0 deg
Other(Type) - Category: Roofs: Gutters; Family Name: Gutter
Construction(Type) - Profile: Profiles_Gutter_Bevel : 150x150mm
Identity Data(Type) - Type Name: Standard

# IfcRoof: Basic Roof:Roof_Generic-125mm, Basic Roof:Roof_Generic-125mm:347485
In: Level 1
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 125 mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Type Name: Roof_Generic-125mm
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 6.72 kg/K/s3; Roughness: 3; Thermal Mass: 190; Thermal Resistance (R): 0.14881 s3*K/kg
Material: Roofing, Tile 125 mm
Pset_QuantityTakeOff - Reference: Roof_Generic-125mm
Pset_RoofCommon - Reference: Roof_Generic-125mm; IsExternal: yes; ProjectedArea: 28.49 m2; TotalArea: 29.3368 m2
Other - Family: Basic Roof; Family and Type: Basic Roof: Roof_Generic-125mm; Type: Roof_Generic-125mm; Type Id: 45396
Constraints - Base Level: Level 1; Base Offset From Level: 2155.65 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 125 mm; Maximum Ridge Height: 6193.17 mm; Rafter Cut: Two Cut - Square
Dimensions - Area: 29.3368 m2; Slope: 0.245624; Thickness: 125 mm; Volume: 3.65233 m3
Phasing - Phase Created: New Construction
